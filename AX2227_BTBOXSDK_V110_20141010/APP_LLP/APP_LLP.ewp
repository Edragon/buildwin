# IAR project APP_LLP.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\
  ICC8051.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\; api\; display\; display\lcdseg\; display\led\; display\lcd\; display\ledseg\; display\no\; common\; task\; user\; user\mp3res\; btstack\; user\user_config
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  postbuild: $TARGET_DIR$\make.bat
  XLINK.XclFile: APP_BASE.xcl
configuration Release (8051)
  as the first configuration, except:
  ICC8051.CCIncludePaths: $TOOLKIT_DIR$\INC\
  ICC8051.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: APP_BASE.xcl APP_LLP.xcl main.c makecfg.c
    Debug/Exe/: hexscript.hs
  group display
    display/: display.c led.c ocx.c
  group display/lcd
    display/lcd/: display_mem.c lcd.c lcd_display.c msgbox.c numbox.c
  group display/lcd/theme_act
    display/lcd/theme_act/: lcd_act_music.c
  group display/lcd/theme_default
    display/lcd/theme_default/: lcd_default_alarm.c lcd_default_bt.c lcd_default_clock.c lcd_default_fm.c lcd_default_menu.c lcd_default_music.c lcd_default_poweroff.c lcd_default_record.c lcd_default_speaker.c lcd_default_updatefw.c lcd_default_usbdev.c
  group display/lcdseg
    display/lcdseg/: lcdseg_display.c lcdseg_listbox.c lcdseg_msgbox.c lcdseg_numbox.c lcdseg_progressbox.c
  group display/lcdseg/theme_default
    display/lcdseg/theme_default/: lcdseg_default_alarm.c lcdseg_default_auxeq.c lcdseg_default_clock.c lcdseg_default_fm.c lcdseg_default_menu.c lcdseg_default_music.c lcdseg_default_updatefw.c lcdseg_default_usbdev.c
  group display/ledseg
    display/ledseg/: led_5c7s.c led_7p7s.c led_seg.c ledseg_display.c ledseg_listbox.c ledseg_msgbox.c ledseg_numbox.c ledseg_progressbox.c
  group display/ledseg/theme_default
    display/ledseg/theme_default/: ledseg_default_alarm.c ledseg_default_auxeq.c ledseg_default_bt.c ledseg_default_clock.c ledseg_default_fm.c ledseg_default_menu.c ledseg_default_music.c ledseg_default_poweroff.c ledseg_default_record.c ledseg_default_showtime.c ledseg_default_speaker.c ledseg_default_updatefw.c ledseg_default_usbdev.c
  group display/no
    display/no/: no_theme.c
  group task
    task/: task.c task_alarm.c task_aux.c task_bt.c task_clock.c task_fm.c task_fm_opa.c task_idle.c task_loudspeaker.c task_mic.c task_music.c task_poweroff.c task_record.c task_recplay.c task_usbdev.c task_voice.c
  group user
    btstack/: BtApi.c
    user/: file_filter.c rtc.c sound_detect.c uart_drv.c user_bt.c user_eq.c user_fat.c user_fm.c user_io.c user_ir.c user_key.c user_key_voice.c user_music.c user_record.c user_rtc.c user_setting.c user_spi.c user_timer.c user_uart.c
  group user/user_config
    user/user_config/: user_cfgdef.h user_config.h user_config_2226_demo.h user_config_2226_demo2.h user_config_2226_s10.h user_config_2226_S10_SIMPLE.h user_config_2227.h user_config_2227_lcd.h user_config_6680E_S10.h user_config_6680E_S10_SIMPLE.h user_config_6681E_Demo.h user_config_6682E.h user_config_cola.h user_config_S10.h
  group user/user_fm
    user/user_fm/: user_fm_ax5111.c user_fm_bk1080.c user_fm_qn8035.c user_fm_qn8065.c user_fm_rda5807.c user_fm_RTC6207.c user_fm_RTC6218.c
